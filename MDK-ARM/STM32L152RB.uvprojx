# Keil uVision project STM32L152RB.uvprojx, settings and files
target Demonstrate (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L152RB
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L1xB, USE_FULL_LL_DRIVER
  c include: ..\inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\Drivers\STM32L1xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
    ../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l152xb.s
  group User
    ../src/: main.c
  group Driver
    ../src/: stm32l1xx_ll_lcd.c stm32l152_glass_lcd.c
    ../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_ll_gpio.c stm32l1xx_ll_pwr.c stm32l1xx_ll_rcc.c stm32l1xx_ll_utils.c stm32l1xx_ll_tim.c dwt_delay.c ESP8266_lowlevel_conf.c stm32l1xx_ll_usart.c
